# Keil uVision project FishDetector.uvprojx, settings and files
target fishDetector (ARM-ADS)
  device: STM32F030K6 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IROM(0x08000000,0x8000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: FishDetector +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\Lib\inc;.\System;.\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group ASM
    ./ASM/: startup_stm32f030.s
  group User
    ./User/: main.c stm32f0xx_it.c gpio.c timer.c uart.c adc.c
  group System
    ./System/: system_stm32f0xx.c
  group Lib
    ./Lib/src/: stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_tim.c stm32f0xx_misc.c stm32f0xx_exti.c stm32f0xx_syscfg.c stm32f0xx_usart.c stm32f0xx_adc.c
software components: CMSIS:CORE 3.40.0
